<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>fc</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>939.4e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value></value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>25</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>75</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>osr</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ppm</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>150</value></param>
<param><key>min</key><value>-150</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>gsm_burst_file_sink</key>
<param><key>id</key><value>gsm_burst_file_sink_0</value></param>
<param><key>filename</key><value>c0.brst</value></param>
</block>
<block>
<key>gsm_bursts_printer</key>
<param><key>id</key><value>gsm_bursts_printer_0</value></param>
<param><key>ignore_dummy_bursts</key><value>False</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>True</value></param>
<param><key>print_payload_only</key><value>False</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>osr</key><value>osr</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0_0</value></param>
</block>
<block>
<key>gsm_extract_immediate_assignment</key>
<param><key>id</key><value>gsm_extract_immediate_assignment_0</value></param>
<param><key>ignore_gprs</key><value>True</value></param>
<param><key>print_immediate_assignments</key><value>True</value></param>
<param><key>unique_references</key><value>False</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>gsm_message_file_sink</key>
<param><key>id</key><value>gsm_message_file_sink_0</value></param>
<param><key>filename</key><value>down.msg</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>prepend_frame_count</key><value>False</value></param>
<param><key>prepend_fnr</key><value>False</value></param>
<param><key>print_gsmtap_header</key><value>False</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>osr</key><value>4</value></param>
</block>
<block>
<key>gsm_sdcch8_demapper</key>
<param><key>id</key><value>gsm_sdcch8_demapper_1</value></param>
<param><key>timeslot_nr</key><value>1</value></param>
</block>
<block>
<key>gsm_tmsi_dumper</key>
<param><key>id</key><value>gsm_tmsi_dumper_0</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>gain</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>freq0</key><value>fc</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>gain</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>fc</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Downlink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>ctrl</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_extract_immediate_assignment_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_file_sink_0</sink_block_id><source_key>msgs</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_tmsi_dumper_0</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_input_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_burst_file_sink_0</sink_block_id><source_key>C0</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_bursts_printer_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_sdcch8_demapper_1</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>gsm_sdcch8_demapper_1</source_block_id><sink_block_id>gsm_control_channels_decoder_0_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
